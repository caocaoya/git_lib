# Keil uVision project Project.uvprojx, settings and files
target STM32105VBT6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F105VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210C_EVAL
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c misc: --C99
  c include: ..\USER\Inc;..\HAERDWEAR\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Drivers_user\DAC;..\Drivers_user\IIC;..\Drivers_user\TIMER;..\Drivers_user\KEY;..\Drivers_user\LED;..\Drivers_user\DMA;..\Drivers_user\DAC;..\Drivers_user\CAN;..\Drivers_user\SPI;..\HAERDWEAR\NB_counmuniction;..\HAERDWEAR\GPS;..\HAERDWEAR\CAN_T-BOX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ./: startup_stm32f105xc.s
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group User
    ../USER/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Drivers_User
    ../Drivers_user/CAN/: can.c
    ../Drivers_user/DAC/: dac.c
    ../Drivers_user/LED/: led.c
    ../Drivers_user/RTC/: rtc.c
    ../Drivers_user/SPI/: spi.c
    ../Drivers_user/TIMER/: timer.c
    ../Drivers_user/DMA/: dma.c
  group HAEDWEAR
    ../HAERDWEAR/NB_counmuniction/: M720_Communication.c
    ../HAERDWEAR/GPS/: GPS_U_BLOX.c
  group STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_usb.c
  group Doc
    ../: 修改记录说明.txt
software components: CMSIS:CORE 5.0.1
